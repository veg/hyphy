/*
	Push button component
	
	Sergei L. Kosakovsky Pond, May 2000 - December 2002.
*/

#include "HYEventTypes.h"
#include "HYButton.h"
#include "HYGraphicPane.h"

#ifdef 	  __HYPHYDMALLOC__
	#include "dmalloc.h"
#endif
//__________________________________________________________________

_HYButton::_HYButton (_HYRect r,Ptr p):_HYComponent (r,p)
{
	backColor.R = backColor.G = backColor.B = 255;
	buttonFont.style = HY_FONT_PLAIN;
	#ifndef __HYPHY_GTK__
		buttonFont.size = 12;
		buttonFont.face = "System Font";
	#else
		buttonFont.size = 10;
		buttonFont.face = _HY_SANS_FONT;
	#endif
	alignFlags = 0;
	buttonKind = 0;
	isEnabled = true;
}

//__________________________________________________________________
			
_HYButton::~_HYButton()
{
}

//__________________________________________________________________

void		_HYButton::SetBackColor (_HYColor c)
{
	if ((c.R!=backColor.R)||(c.G!=backColor.G)||(c.B!=backColor.B))
	{
		backColor = c;
		_SetBackColor (c);
		_MarkForUpdate();
	}
}

//__________________________________________________________________

_HYColor&		_HYButton::GetBackColor (void)
{
	return backColor;
}		

//__________________________________________________________________
void			_HYButton::SetText (_String newText)
{
	buttonText = newText;
	_SetText ();
	_MarkForUpdate();
}

//__________________________________________________________________

_String&		_HYButton::GetText (void)
{
	return buttonText;
}

//__________________________________________________________________
  
_HYFont&		_HYButton::GetFont (void)
{
	return buttonFont;
}

//__________________________________________________________________

void			_HYButton::SetFont (_HYFont&f)
{
	if ((f.face!=buttonFont.face)||(f.size!=buttonFont.size)||(f.style!=buttonFont.style))
	{
		_SetFont (f);
		buttonFont.face = f.face;
		buttonFont.size = f.size;
		buttonFont.style = f.style;
		_MarkForUpdate();
	}
}

//__________________________________________________________________
void			_HYButton::SetVisibleSize (_HYRect rel)
{
	_HYComponent::SetVisibleSize (rel);
	_HYPlatformButton::_SetVisibleSize (rel);
}



//__________________________________________________________________

void			_HYButton::EnableButton (bool e)
{	
	if (isEnabled!=e)
	{
		isEnabled = e;
		_EnableButton (e);
	}
}	

//__________________________________________________________________

void			_HYButton::SetButtonKind (unsigned char k)
{	
	if (buttonKind != k)
	{
		buttonKind = k;
		_SetButtonKind (k);
	}
}
